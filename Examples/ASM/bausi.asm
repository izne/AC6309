		ORG 	$1954

ACIA_C 	EQU 	$A000 				; ACIA control register address
ACIA_D 	EQU 	$A001 				; ACIA data register address	

Start	LDX 	#DATA 				; Load address of DATA
Loop    LDA 	,x 					; Load the next character from DATA
        BEQ 	End 				; If it's the null terminator, branch to END
        STA 	ACIA_D 				; Send the character to ACIA_D
        JSR 	Delay 				; Introduce a delay
        LEAX 	1, x 				; Move to the next character in DATA
        BRA 	Loop 				; Repeat for the next character
		
End		RTS  						; Return

Delay   LDA 	#100 				; Delay between character output 
Delay_Loop
        SUBA	#1					; Decrement the counter
        BNE 	Delay_Loop 			; Repeat until the counter is zero
        RTS 						; Return from subroutine

DATA	
		FCC "                                                                                ", $0A, $0D
		FCC "                           ,....,***/*,**//*(*,....,,.                          ", $0A, $0D
		FCC "                      **/((#80000000008888888888888%8%#(*.  .                   ", $0A, $0D
		FCC "                 **/(%000888888%%%########%%%88%%%%8888%%8%(*..,                ", $0A, $0D
		FCC "               *,*%0888800000088%%888888%%%%8%%%%%%%%%88888880%#(               ", $0A, $0D
		FCC "            ,,/#0088880008888888888%88%%%%%%%%%%%%#%%%%%800000000%(             ", $0A, $0D
		FCC "          .,(8008888888888888888888%#%###%%###%#%####%8%%8888000000%(/          ", $0A, $0D
		FCC "        .,/%808%%%888%8%%%%%%%%%%##%%##################%%%88888888008(/*        ", $0A, $0D
		FCC "        ./%80%####(((((#((##(###((((((((((#(##(((((((((((#888888888800#//       ", $0A, $0D
		FCC "       ./%80(/(((((((((((((((/////////((((((((((((////////(#%8888888880%(       ", $0A, $0D
		FCC "       .#%8(///(((((((((((///////////////*//////*//////////((#%%8%%88%88(*      ", $0A, $0D
		FCC "       /%%(/////////(///////////////////****//////********//(((###%%88%88#      ", $0A, $0D
		FCC "     .,(%(**********/((/******//((((((//////////***//*******/(((###%%%%%%##     ", $0A, $0D
		FCC "      ,##/***********///((//((((((((((((((/////**/////*******///(((###%%%(,     ", $0A, $0D
		FCC "    . *#(**********////((((///**///////////////////////*/******//((((####*      ", $0A, $0D
		FCC "    . ,#(*/*******/////////////*******,,,,.,...,,,,**////**/****////(((((#,     ", $0A, $0D
		FCC "     .,/(/**//////***************,,,,.... .  .....,,,**////*//**/////((((,      ", $0A, $0D
		FCC "     . ,(////////****,*,,,*,,*,,*,,,....,,...,,,,,,,,,,*****//**/(((///****,    ", $0A, $0D
		FCC "        .///**,,..,. . .....,,**,,,,,....  .      ...,..,,***//**/((#/*,,,*,    ", $0A, $0D
		FCC "        .*/**,,,......    ...,****,,,.... .,,....,,,,,,,,,*******/((#/,,,,*,    ", $0A, $0D
		FCC "       ../(/*,,,,..,.    .. ,/////*,,,,....,,,,,,,******///*******/(#(..,,,*    ", $0A, $0D
		FCC "        ./(*,,,........,....///((/*******,,,,,*********/////********/*...,,.    ", $0A, $0D
		FCC "        .*(/**,,,,,,,,,,,,,*/(((//****/****//***********************/*,,,,,     ", $0A, $0D
		FCC "          ((****************(#((((/********//////////*******************/*,     ", $0A, $0D
		FCC "          */*************,,/(((((((/*//*,.,***///////////*************//*,      ", $0A, $0D
		FCC "            *****///****,,***********///*,,,,,*****/////////************.       ", $0A, $0D
		FCC "            ****////**,,,,*,,*****,.....,***,,,,*****////*************/*        ", $0A, $0D
		FCC "            ****//***,,,,**,,,,,,,,,,,********,,,**********************/        ", $0A, $0D
		FCC "             ********,,,****,,,,,,,,,,,,,******,,,,,******************/         ", $0A, $0D
		FCC "             (/******,,,**,**,,,,,..,,,,,,,,,,,,,,,,,,****************/#%(      ", $0A, $0D
		FCC "              ((*****,,,****,,.,,,,,..  .........,,,,*******************,(8#/   ", $0A, $0D
		FCC "                ****,,,,,..,,,,,,,,,,,,,**,,,,**,,.,,,*,,******,,,,***,*(%%%%/,,", $0A, $0D
		FCC "                 ,*****,,,,,,,,*,,,,,,,,,,,,,,,,,,,,,,,,,,***,,,,,,,,.,(%%##%%/(", $0A, $0D
		FCC "                  .****,,**,,,,,,,,,,,,****,******,,,,,,,,*,,,,,,,,,.,(####%%88#", $0A, $0D
		FCC "                   .******,*********************,*,,,,,,,,,,,,,,....*##(((///(#%", $0A, $0D
		FCC "                  .,****,,,***********,,********,,,,,,,,,,,,,,... ,(##(/**(#####", $0A, $0D
		FCC "                  ,,(8(,,,,,********,,,,,,,,,,,,,,,,,,,,,,....   *##(/,*(###%##%", $0A, $0D
		FCC "                ,#8%%#/(/,,,,,,,,,,,,,,,,,,,,,,,,,,,,,.....  . ,(#(/***(#####%%%", $0A, $0D
		FCC "            /*#8%##((((##/,,*,,,,,,,,,,,,,,,,,,,........  .  *##(//**/(((#(/(((#", $0A, $0D
		FCC "          .(8%(((##(#%(*,,.,/,,,,,,,,,,,,,,.............. ./%#(//////((#((##(/(#", $0A, $0D
		FCC "        #08(##((#%%(/***,.,(/*,,,,,,,,,,,,,,,,...........(%#((/////(((#(((((#%##", $0A, $0D
		FCC "    (%8%#(##((#%#(///***.,//**,,,,,,,,,...............,(##((//////((((((((######", $0A, $0D
		FCB $04
		FCB 0